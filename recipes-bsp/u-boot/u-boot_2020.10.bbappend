FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
	file://0001-configs-rzg2l-Modify-environment-to-work-with-the-Ba.patch \
"
