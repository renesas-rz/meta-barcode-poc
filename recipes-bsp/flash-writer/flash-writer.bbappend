do_compile_prepend_barcode-poc-g2l() {
	BOARD="RZG2L_SMARC"
	PMIC_BOARD="RZG2L_SMARC_PMIC"
}
