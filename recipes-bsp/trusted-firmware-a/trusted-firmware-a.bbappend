COMPATIBLE_MACHINE = "(smarc-rzg2l|rzg2l-dev|smarc-rzg2lc|rzg2lc-dev|barcode-poc-g2l)"

PLATFORM_barcode-poc-g2l = "g2l"
EXTRA_FLAGS_barcode-poc-g2l = "BOARD=smarc_2"
PMIC_EXTRA_FLAGS_barcode-poc-g2l = "BOARD=smarc_pmic_2"
FLASH_ADDRESS_BL2_BP_barcode-poc-g2l = "00000"
FLASH_ADDRESS_FIP_barcode-poc-g2l = "1D200"
